# Keil uVision project EBC_8.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR32F8 Milandr
  pack: Keil.MDR32F8.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x20006000,0x2000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: EBC_8
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x20006000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group user
    ./: main.c Clock_VE8.c ExtBus_VE8.c Btn_LED_VE8.c
software components: Board Support:Board Setup 0.0.1, Device:Startup 0.0.1, Drivers:CLKCTRL 0.0.1, Drivers:EBC 0.0.1, Drivers:PORT 0.0.1
